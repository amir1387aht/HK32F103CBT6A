<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HK32F103xxxxA_Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
