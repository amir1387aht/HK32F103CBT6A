# Keil uVision project HK32F103xxxxA_Demo.uvprojx, settings and files
target HK32F103xxxxA_Demo_I2C_Master (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32F103VET6 HK_MicroChip
  pack: HKMicroChip.HK32F103xxxxA_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HK32F103xxxxA_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT,IIC_MODE=MASTER_MODE
  c include: ..\..\..\..\..\Libraries\CMSIS\CM3\Core;..\..\..\..\..\Libraries\CMSIS\HK32F103xxxxA\Include;..\..\..\..\..\Libraries\HK32F103xxxxA_StdPeriphDriver\inc;..\inc;..\..\..\..\..\Boards\HK32F103(39A)VExxx_Ver1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ../../../../../Libraries/CMSIS/HK32F103xxxxA/Source/ARM/: startup_hk32f103xxxxa.s
  group Src
    ../src/: main.c hk32f103xxxxa_it.c
    ../../../../../Libraries/CMSIS/HK32F103xxxxA/Source/: system_hk32f103xxxxa.c
  group HK32F103xxxxA_lib
    ../../../../../Libraries/HK32F103xxxxA_StdPeriphDriver/src/: hk32f103xxxxa_adc.c hk32f103xxxxa_bkp.c hk32f103xxxxa_cache.c hk32f103xxxxa_can.c hk32f103xxxxa_crc.c hk32f103xxxxa_dac.c hk32f103xxxxa_dbgmcu.c hk32f103xxxxa_dma.c hk32f103xxxxa_exti.c hk32f103xxxxa_flash.c hk32f103xxxxa_fsmc.c hk32f103xxxxa_gpio.c hk32f103xxxxa_i2c.c hk32f103xxxxa_iwdg.c hk32f103xxxxa_misc.c hk32f103xxxxa_pwr.c hk32f103xxxxa_rcc.c hk32f103xxxxa_rtc.c hk32f103xxxxa_sdio.c hk32f103xxxxa_spi.c hk32f103xxxxa_tim.c hk32f103xxxxa_uid.c hk32f103xxxxa_usart.c hk32f103xxxxa_wwdg.c
  group Boards
    ../../../../../Boards/HK32F103(39A)VExxx_Ver1/: hk32f103xxxxa_eval.c
  group Doc
    ../: Readme.txt
target HK32F103xxxxA_Demo_I2C_Slave (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32F103VET6 HK_MicroChip
  pack: HKMicroChip.HK32F103xxxxA_DFP.1.0.0
  cpu: as above
  output: HK32F103xxxxA_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT,IIC_MODE=SLAVE_MODE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
