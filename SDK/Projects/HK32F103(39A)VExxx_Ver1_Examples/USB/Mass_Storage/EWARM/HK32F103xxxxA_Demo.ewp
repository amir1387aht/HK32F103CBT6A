# IAR project HK32F103xxxxA_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HK32F103VET6 HSXP-HK HK32F103VET6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Libraries\CMSIS\HK32F103xxxxA\Include; ..\..\..\..\..\Libraries\HK32F103xxxxA_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\CM3\Core; ..\..\..\..\..\Boards\HK32F103(39A)VExxx_Ver1; ..\..\..\..\..\Libraries\HK32F103xxxxA-USB-FS-Device-Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HK32AUTO39A3X_Demo.srec
  ILINK.IlinkOutputFile: HK32F103xxxxA_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boards
    ../../../../../Boards/HK32F103(39A)VExxx_Ver1/: hk32f103xxxxa_eval.c hk32f103xxxxa_eval_sdio_sd.c
  group Doc
    ../: Readme.txt
  group Library
    ../../../../../Libraries/HK32F103xxxxA_StdPeriphDriver/src/: hk32f103xxxxa_adc.c hk32f103xxxxa_bkp.c hk32f103xxxxa_cache.c hk32f103xxxxa_can.c hk32f103xxxxa_crc.c hk32f103xxxxa_dac.c hk32f103xxxxa_dbgmcu.c hk32f103xxxxa_dma.c hk32f103xxxxa_exti.c hk32f103xxxxa_flash.c hk32f103xxxxa_fsmc.c hk32f103xxxxa_gpio.c hk32f103xxxxa_i2c.c hk32f103xxxxa_iwdg.c hk32f103xxxxa_misc.c hk32f103xxxxa_pwr.c hk32f103xxxxa_rcc.c hk32f103xxxxa_rtc.c hk32f103xxxxa_sdio.c hk32f103xxxxa_spi.c hk32f103xxxxa_tim.c hk32f103xxxxa_uid.c hk32f103xxxxa_usart.c hk32f103xxxxa_wwdg.c
  group Startup
    ../../../../../Libraries/CMSIS/HK32F103xxxxA/Source/IAR/: IAR_Startup_hk32f103xxxxa.s
  group USB_FS_Device_Driver
    ../../../../../Libraries/HK32F103xxxxA-USB-FS-Device-Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: hk32f103xxxxa_it.c hw_config.c main.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
    ../../../../../Libraries/CMSIS/HK32F103xxxxA/Source/: system_hk32f103xxxxa.c
